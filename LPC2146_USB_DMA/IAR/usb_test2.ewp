# IAR project usb_test2.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpannl8n.h
  General.OGChipSelectEditMenu: LPC2148 Philips LPC2148
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lpc2146_flash.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.r79
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: startup_hardware_init.s79 tnkernel_startup_iar.s79
  group Test files
    ../usb_tests/: tn_usb_descr.c tn_usb_ep_dma.c tn_usb_hw.c tn_usb_req.c tn_user.c usb_tst2.c utils.c
  group TNKernel21
    ../../TNKernel/: tn.c tn_dqueue.c tn_event.c tn_mem.c tn_mutex.c tn_port.c tn_port_asm.s79 tn_sem.c tn_tasks.c tn_utils.c
