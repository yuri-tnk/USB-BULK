<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>F:\TNKernel_v21\LPC2146_USB\IAR\usb_test1.ewp</path>
  </project>
  <batchBuild/>
</workspace>


